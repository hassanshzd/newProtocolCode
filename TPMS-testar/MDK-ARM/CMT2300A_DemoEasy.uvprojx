# Keil uVision project CMT2300A_DemoEasy.uvprojx, settings and files
target CMT2300A_DemoEasy (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMT2300A_DemoEasy +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\M3;..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\INC;..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\LIB;..\Libraries\STM32F10x_StdPeriph_DriverFWLib3.5\Startup;..\USER;..\USER\platform;..\USER\services;..\USER\periph;..\USER\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32F10x_StdPeriph_DriverFWLib3.5
    ../Libraries/STM32F10x_StdPeriph_DriverFWLib3.5/Startup/: startup_stm32f10x_hd.s
    ../Libraries/STM32F10x_StdPeriph_DriverFWLib3.5/M3/: core_cm3.c
    ../Libraries/STM32F10x_StdPeriph_DriverFWLib3.5/LIB/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_exti.c
  group platform
    ../USER/platform/: common.c main.c stm32f10x_it.c system.c system_stm32f10x.c
  group periph
    ../USER/periph/: buzzer.c lcd12864.c led.c cmt_spi3.c uart.c
  group services
    ../USER/services/: time_server.c interrupt_server.c key_server.c user.c user.h
  group radio
    ../USER/radio/: radio.c cmt2300a.c cmt2300a_hal.c
software components: CMSIS:CORE 5.5.0
